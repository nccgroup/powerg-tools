options:
  parameters:
    generate_options: no_gui
    id: send_pkt
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: bottom_freq
  id: variable
  parameters:
    value: '912749725'
  states: {}
- name: chan_spacing
  id: variable
  parameters:
    value: '129730'
  states: {}
- name: channels
  id: variable
  parameters:
    value: '[bottom_freq + chan_id * chan_spacing for chan_id in range(num_channels)]'
  states: {}
- name: fsk_deviation
  id: variable
  parameters:
    value: '25000'
  states: {}
- name: num_channels
  id: variable
  parameters:
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: symbol_rate * samples_per_symbol
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: '40'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation)
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: test_pkt_whitened.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: samples_per_symbol
    sensitivity: (2 * math.pi * fsk_deviation) / (samp_rate)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '0'
    freq0: channels[0]
    gain0: '14'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    name: '"GFSK"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}

connections:
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', digital_gfsk_mod_0, '0']
- [blocks_multiply_const_vxx_0, '0', osmosdr_sink_0, '0']
- [digital_gfsk_mod_0, '0', analog_quadrature_demod_cf_0, '0']
- [digital_gfsk_mod_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
