options:
  parameters:
    generate_options: no_gui
    id: send_pkt
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: bottom_freq
  id: variable
  parameters:
    value: '912749725'
  states: {}
- name: chan_spacing
  id: variable
  parameters:
    value: '129730'
  states: {}
- name: channels
  id: variable
  parameters:
    value: '[bottom_freq + chan_id * chan_spacing for chan_id in range(num_channels)]'
  states: {}
- name: fsk_deviation
  id: variable
  parameters:
    value: '25000'
  states: {}
- name: num_channels
  id: variable
  parameters:
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: symbol_rate * samples_per_symbol
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: '40'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation)
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: test_pkt_payload_only.bin
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: Packet length is fixed to match input length for these test blocks
    len_tag_key: '"packet_len"'
    packet_len: '18'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: (17, 1, 10, 253, 0, 78, 0, 128, 91, 45, 184, 30, 179, 0, 4, 119, 255, 0)
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: samples_per_symbol
    sensitivity: (2 * math.pi * fsk_deviation) / (samp_rate)
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\nimport pmt\nimport numpy as np\n\nfrom gnuradio import gr\nfrom crc import Calculator, Configuration\n\n\nCRC_CONFIG = Configuration(\n    width=16,\n    polynomial=0x8005,\n    init_value=0xffff,\n    final_xor_value=0x0000,\n    reverse_input=False,\n    reverse_output=False,\n)\n\nCRC16_CC1101 = Calculator(CRC_CONFIG)\n\nPREGEN_DEWHITEN = bytes.fromhex('ffe11d9aed853324ea7ad2397097570a547d2dd86d0dba8f6759c7a2bf34ca18305393df92eca7158adcf486554e182140c4c4d5c6918acde7d14e093217df83fff00ecdf6c21912753de91cb8cb2b05aabe16ecb606ddc7b3ac63d15f1a650c98a9c96f49f6d30a456e7ac32a278c102062e26ae348c5e6f368a704998befc17f7887667be10c89ba9e740edce59502555f0b765b83eee359d6b1e82f8d3206ccd4e4b724fb69852237bd6195134608103171b571a462f379b45382ccc5f7e03fbc43b3bd7086445d4f3a07eef24a81aaaf05bbad41f7f12ceb58f497461903666af25b92fdb442919bdeb0ca0923048898b8da3852b1f93cda2941e6e27bf01fdea1d9')\n\n\ndef cc1101_whiten(data):\n    return [int(b ^ PREGEN_DEWHITEN[i]) for i, b in enumerate(data)]\n\n\ndef crc16(data):\n    return CRC16_CC1101.checksum(data)\n\n\nclass cc1101_pkt_prep(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Prepend preamble and sync word, calculate CC1101 CRC-16, and perform CC1101 whitening on packet payload\"\"\"\n\n    def __init__(self):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='PDU CC1101 Packet Prep',   # will show up in GRC\n            in_sig=None,\n            out_sig=None\n        )\n        \n        self.preamble = b'\\xAA\\xAA\\xAA\\xAA'\n        self.sync_word = b'\\x1F\\x35\\x1F\\x35'\n        \n        self.msg_port_in_name = pmt.intern('pdu_in')\n        self.msg_port_out_name = pmt.intern('pdu_out')\n        self.message_port_register_in(self.msg_port_in_name)\n        self.message_port_register_out(self.msg_port_out_name)\n        self.set_msg_handler(self.msg_port_in_name, self.message_handler)\n        \n    def message_handler(self, msg):\n        meta = pmt.car(msg)\n        data = pmt.cdr(msg)\n        \n        bytez = bytes(pmt.u8vector_elements(data))\n   \n        out_meta = pmt.dict_add(meta, pmt.intern('cc1101_whitened'), pmt.to_pmt(True)) \n        out_meta = pmt.dict_add(out_meta, pmt.intern('cc1101_crc16'), pmt.to_pmt(True))\n\n        crc_bytes = crc16(bytez).to_bytes(2, 'big')\n        full_pkt = list(self.preamble) + list(self.sync_word) + cc1101_whiten(list(bytez) + list(crc_bytes))\n        out_data = pmt.init_u8vector(len(full_pkt), full_pkt)\n        \n        #print(f'cc1101 prep input payload: {bytez.hex()}')\n        #print(f'crc-16 bytes: {crc_bytes.hex()}')\n        #print(f'cc1101 prep output: {bytes(full_pkt).hex()}')\n\n        out_msg = pmt.cons(out_meta, out_data)\n\n        self.message_port_pub(self.msg_port_out_name, out_msg)\n\n"
    comment: Must install Python3 crc module (https://github.com/Nicoretti/crc) in GNU Radio's Python path
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '0'
    freq0: channels[0]
    gain0: '14'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    name: '"GFSK"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: packet_payload_pdus
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: tx_bytes
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: packet_payload_pdus
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: tx_bytes
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_throttle2_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_throttle2_0, '0', qtgui_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [digital_gfsk_mod_0, '0', blocks_throttle2_0, '0']
- [digital_gfsk_mod_0, '0', osmosdr_sink_0, '0']
- [epy_block_0_0, pdu_out, pdu_pdu_to_stream_x_0, pdus]
- [pdu_pdu_to_stream_x_0, '0', virtual_sink_1, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, virtual_sink_0, '0']
- [virtual_source_0, '0', epy_block_0_0, pdu_in]
- [virtual_source_1, '0', digital_gfsk_mod_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
