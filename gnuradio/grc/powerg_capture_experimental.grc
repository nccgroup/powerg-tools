options:
  parameters:
    author: James Chambers
    copyright: NCC Group 2024
    generate_options: qt_gui
    id: powerg_capture_experimental
    output_language: python
    title: PowerG Capture (Experimental)
  states: {}

blocks:
- name: bottom_freq
  id: variable
  parameters:
    value: '912749725'
  states: {}
- name: bp_transition_width
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: overall_center_freq
  states: {}
- name: chan_center_freq
  id: variable
  parameters:
    value: bottom_freq + chan_id * chan_spacing
  states: {}
- name: chan_id
  id: variable
  parameters:
    value: variable_qtgui_range_channel
  states: {}
- name: chan_spacing
  id: variable
  parameters:
    value: '129730'
  states: {}
- name: decimated_samp_rate
  id: variable
  parameters:
    value: samp_rate / decimation_rate
  states: {}
- name: decimation_rate
  id: variable
  parameters:
    value: int(samp_rate / (samp_bandwidth*1))
  states: {}
- name: deviation_for_freq
  id: variable
  parameters:
    value: oscillator_deviation * center_freq
  states: {}
- name: fft_vec_sz
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: gfsk_sens
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_0@1
    label: GFSK Sensitivity
    start: '0.1'
    step: '0.1'
    stop: '10'
    value: '1.0'
  states: {}
- name: n_cfo_est_avg
  id: variable
  parameters:
    value: '16'
  states: {}
- name: n_ffts_avg
  id: variable
  parameters:
    value: '16'
  states: {}
- name: num_channels
  id: variable
  parameters:
    value: '50'
  states: {}
- name: oscillator_deviation
  id: variable
  parameters:
    value: 20/1000000
  states: {}
- name: overall_center_freq
  id: variable
  parameters:
    value: bottom_freq + (chan_spacing * (num_channels-1)) / 2
  states: {}
- name: samp_bandwidth
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '8000000'
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: int(decimated_samp_rate // symbols_per_second)
  states: {}
- name: symbols_per_second
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: variable_qtgui_range_channel
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_0@0
    label: Channel ID
    rangeType: int
    start: '0'
    step: '1'
    stop: num_channels - 1
    value: '15'
  states: {}
- name: variable_qtgui_range_loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_0@1
    label: Loop Bandwidth
    start: math.pi / 200
    step: '0.0001'
    stop: (2*math.pi) / 100
    value: '0.026008'
  states: {state: disabled}
- name: variable_qtgui_range_shift
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_0@1
    label: Shift input
    start: '-100000'
    step: '1000'
    stop: '100000'
    value: '0'
  states: {}
- name: variable_qtgui_range_squelch_db
  id: variable_qtgui_range
  parameters:
    gui_hint: qtgui_tab_widget_0@1
    label: Squelch threshold
    start: '-100'
    step: '1'
    stop: '0'
    value: '-25'
  states: {}
- name: variable_qtgui_range_ted_gain
  id: variable_qtgui_range
  parameters:
    label: TED Gain
    start: '0'
    step: '0.001'
    stop: '1'
    value: '1.0'
  states: {state: disabled}
- name: variable_qtgui_range_trigger
  id: variable_qtgui_range
  parameters:
    label: Trigger
    start: '-1'
    step: '0.1'
    stop: '1'
    value: '0.3'
  states: {state: disabled}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_quadrature_demod_cf_1
  id: analog_quadrature_demod_cf
  parameters:
    comment: For showing raw quad demod output
    gain: '1'
  states: {}
- name: analog_quadrature_demod_cf_1_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: variable_qtgui_range_squelch_db
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: decimation_rate
    gain: '1'
    high_cutoff_freq: (chan_center_freq - center_freq) + (chan_spacing/2)
    low_cutoff_freq: (chan_center_freq - center_freq) - (chan_spacing/2)
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: bp_transition_width
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: blocks_burst_tagger_0
  id: blocks_burst_tagger
  parameters:
    false_key: sync
    false_value: 'False'
    true_key: sync
    true_value: 'True'
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_vec_sz
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: fft_vec_sz
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /tmp/powerg_bits
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    file: /tmp/powerg_bytes
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    offset: int(samp_rate)* 0
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    comment: Manual CFO fix
    freq: variable_qtgui_range_shift
    sample_rate: decimated_samp_rate
  states: {}
- name: blocks_moving_average_xx_0_1
  id: blocks_moving_average_xx
  parameters:
    length: n_ffts_avg
    max_iter: '4000'
    scale: 1/n_ffts_avg
    type: float
    vlen: fft_vec_sz
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: n_cfo_est_avg
    max_iter: '4000'
    scale: 1/n_cfo_est_avg
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1/fft_vec_sz
    type: complex
    vlen: fft_vec_sz
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: samples_per_symbol
    type: float
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    comment: Estimator outputs one CFO val per group of FFT inputs
    interp: fft_vec_sz
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_vec_sz
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: 0.175*2
    mu: '0.5'
    omega_relative_limit: (20/1e6)*2
    samples_per_symbol: samples_per_symbol
    sensitivity: gfsk_sens
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: samples_per_symbol
    resamp_type: digital.IR_MMSE_8TAP
    sps: samples_per_symbol
    ted_gain: '1.0'
    ted_type: digital.TED_EARLY_LATE
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"CFO Estimator (RMS)\"\"\"\n\n    def __init__(self, vector_size=2048, sample_rate=10000, center_freq=0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='CFO Estimator (RMS)',   # will show up in GRC\n            in_sig=[(np.float32, vector_size)],\n            out_sig=[np.float32]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.vector_size = vector_size\n        self.sample_rate = sample_rate\n        self.center_freq = center_freq\n        \n        self._start_freq = self.center_freq - (self.sample_rate / 2)\n        self.freq_axis = [self._start_freq + (self.sample_rate/self.vector_size) * x for x in range(self.vector_size)]\n\n    def work(self, input_items, output_items):\n        \"\"\"Estimate offset with RMS on FFT outputs\"\"\"\n\n        for vec_i, vector in enumerate(input_items[0]):\n            energy = 0\n            top_integral = 0\n\n            # mag^2 output per FFT bin\n            for i, mag in enumerate(vector):\n                energy += mag\n                top_integral += mag * self.freq_axis[i]\n            \n            if energy == 0:\n                cf_estimate = 0\n            else:\n                cf_estimate = top_integral / energy\n            \n            output_items[0][vec_i] = cf_estimate\n                \n        return len(output_items[0])\n\n"
    center_freq: '0'
    sample_rate: decimated_samp_rate
    vector_size: fft_vec_sz
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"CFO Correction (Hz)\"\"\"\n\n    def __init__(self, sample_rate=32000, max_shift=19000):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='CFO Correct',   # will show up in GRC\n            in_sig=[np.complex64, np.float32],\n            out_sig=[np.complex64]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.sample_rate = sample_rate\n        self.max_shift = max_shift\n        \n    def rads_to_hz(self, rads):\n    \treturn (rads / (2*np.pi)) * self.sample_rate\n\n    def work(self, input_items, output_items):\n        \"\"\"CFO correct samples using frequency offset estimation\"\"\"\n\n        for n, offset in enumerate(input_items[1]):\n        \tif offset < (-self.max_shift):\n        \t    offset = -self.max_shift\n        \telif offset > self.max_shift:\n        \t    offset = self.max_shift\n        \t\n        \tshift_amt = np.e ** (1j * np.pi * (-offset / (self.sample_rate/2)) * n)\n        \t\n        \toutput_items[0][n] = input_items[0][n] * shift_amt\n        \n        return len(output_items[0])\n        \n"
    max_shift: deviation_for_freq
    sample_rate: decimated_samp_rate
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, sync_word=0x1F351F35, sync_bits=32):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Sync Word Finder',   # will show up in GRC\n            in_sig=[np.ubyte],\n            out_sig=[np.short]\n        )\n        \n        if sync_word == 0:\n            raise Exception('sync word of 0 not supported')\n        \n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.sync_word = sync_word\n        self.sync_bits = sync_bits\n        \n        # register for shifting in sync word\n        self.sync_mask = 2**self.sync_bits - 1\n        self.shift_reg = 0\n        \n        # shift in data bytes\n        self.shift_byte = 0\n        self.shift_byte_bits = 0\n        \n        self.pkt_len = 0\n        \n        self.sync_state = 0\n\n    def work(self, input_items, output_items):\n    \n        # output byte array\n        #output_items[1] = []\n\n        for i, bit in enumerate(input_items[0]):\n            \n            # find sync word\n            if self.sync_state == 0:\n                self.shift_reg = ((self.shift_reg << 1) | (bit & 1)) & self.sync_mask\n                \n                if self.shift_reg == self.sync_word:\n                    output_items[0][i] = 1\n                    \n                    # transition to state 1\n                    self.sync_state = 1\n                    self.shift_byte = 0\n                    self.shift_byte_bits = 0\n                    continue\n                else:\n                    output_items[0][i] = 0\n                    \n            # shift in length byte\n            if self.sync_state == 1:\n                self.shift_byte = ((self.shift_byte << 1) | (bit & 1)) & 0xFF\n                self.shift_byte_bits += 1\n                \n                output_items[0][i] = 1\n                \n                if self.shift_byte_bits == 8:\n                    #output_items[1].append(self.shift_byte)\n                    \n                    # first CC1101 whitening mask byte is always 0xFF\n                    self.pkt_len = self.shift_byte ^ 0xFF\n                    #print(f'packet length byte {self.shift_byte:#04x}: {self.pkt_len} ({self.pkt_len * 8} bits)')\n                    \n                    # transition to state 2\n                    self.shift_byte = 0\n                    self.shift_byte_bits = 0\n                    self.sync_state = 2\n                    continue\n \n            # consume data bytes\n            if self.sync_state == 2:\n                self.shift_byte = ((self.shift_byte << 1) | (bit & 1)) & 0xFF\n                self.shift_byte_bits += 1\n                \n                output_items[0][i] = 1\n                \n                #if self.shift_byte_bits & 7 == 0:\n                    #print(self.shift_byte)\n                    #output_items[1].append(self.shift_byte)\n                \n                if self.shift_byte_bits == self.pkt_len * 8:\n                    # transition to state 0\n                    self.shift_reg = 0\n                    self.sync_state = 0\n                    continue\n \n        return len(output_items[0])\n\n"
    sync_bits: '32'
    sync_word: '523575093'
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass powerg_sync_blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"PowerG: output packets on sync word\"\"\"\n\n    def __init__(self, sync_word=0x1F351F35, sync_bits=32):\n        gr.basic_block.__init__(\n            self,\n            name='PowerG Sync Output',   # will show up in GRC\n            in_sig=[np.ubyte],\n            out_sig=[np.ubyte]\n        )\n        \n        if sync_word == 0:\n            raise Exception('sync word of 0 not supported')\n        \n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.sync_word = sync_word\n        self.sync_bits = sync_bits\n        \n        # register for shifting in sync word\n        self.sync_mask = 2**self.sync_bits - 1\n        self.shift_reg = 0\n        \n        # shift in data bytes\n        self.shift_byte = 0\n        self.shift_byte_bits = 0\n        \n        self.pkt_len = 0\n        \n        self.sync_state = 0\n\n    def general_work(self, input_items, output_items):\n        out_i = 0\n\n        for i, bit in enumerate(input_items[0]):\n            self.consume(0, 1)\n            \n            # find sync word\n            if self.sync_state == 0:\n                self.shift_reg = ((self.shift_reg << 1) | (bit & 1)) & self.sync_mask\n                \n                if self.shift_reg == self.sync_word:\n                    # transition to state 1\n                    self.sync_state = 1\n                    self.shift_byte = 0\n                    self.shift_byte_bits = 0\n                    continue\n                    \n            # shift in length byte\n            if self.sync_state == 1:\n                self.shift_byte = ((self.shift_byte << 1) | (bit & 1)) & 0xFF\n                self.shift_byte_bits += 1\n                \n                if self.shift_byte_bits == 8:\n                    output_items[0][out_i] = self.shift_byte\n                    out_i += 1\n                    \n                    # first CC1101 whitening mask byte is always 0xFF\n                    # add 2 for CRC-16 bytes\n                    self.pkt_len = (self.shift_byte ^ 0xFF) + 2\n                    #print(f'packet length byte {self.shift_byte:#04x}: {self.pkt_len} ({self.pkt_len * 8} bits)')\n                    \n                    # transition to state 2\n                    self.shift_byte = 0\n                    self.shift_byte_bits = 0\n                    self.sync_state = 2\n                    continue\n \n            # consume data bytes\n            if self.sync_state == 2:\n                self.shift_byte = ((self.shift_byte << 1) | (bit & 1)) & 0xFF\n                self.shift_byte_bits += 1\n                \n                if self.shift_byte_bits & 7 == 0:\n                    #print(self.shift_byte)\n                    output_items[0][out_i] = self.shift_byte\n                    out_i += 1\n                \n                if self.shift_byte_bits == self.pkt_len * 8:\n                    # transition to state 0\n                    self.shift_reg = 0\n                    self.sync_state = 0\n                    continue\n \n        #return len(output_items[0])\n        return out_i\n\n"
    sync_bits: '32'
    sync_word: '523575093'
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_vec_sz
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_vec_sz)
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: chan_center_freq - center_freq
    decim: decimation_rate
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, -(chan_spacing/2), chan_spacing/2, bp_transition_width)
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: symbols_per_second
    gain: '1'
    interp: '1'
    samp_rate: decimated_samp_rate
    type: interp_fir_filter_fff
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0
    bb_gain0: '20'
    dc_offset_mode0: '1'
    freq0: center_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: decimated_samp_rate
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: 'qtgui_tab_widget_0@1 : 0, 0, 1, 1'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: decimated_samp_rate
    fc: center_freq
    fftsize: '4096'
    gui_hint: 'qtgui_tab_widget_0@1 : 0, 0, 1, 1'
    name: '"band pass filter"'
    plotconst: 'False'
    plottime: 'False'
    showrf: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: qtgui_tab_widget_0@0
    name: '"RF Samples"'
    plotconst: 'False'
    plottime: 'False'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_0_1
  id: qtgui_sink_x
  parameters:
    bw: decimated_samp_rate
    fc: center_freq -  variable_qtgui_range_shift
    fftsize: '4096'
    gui_hint: 'qtgui_tab_widget_0@1 : 0, 1, 1, 1'
    name: '"band pass filter - freq adjust"'
    plottime: 'False'
    type: complex
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    label0: Capture
    label1: Decode
    num_tabs: '2'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.5'
    alpha2: '0.5'
    color1: red
    color2: blue
    grid: 'True'
    gui_hint: 'qtgui_tab_widget_0@1 : 2,0,1,2'
    label1: Quad Demod
    label2: Binary Slicer
    name: '"Quadrature Demod"'
    nconnections: '2'
    size: '1024'
    srate: decimated_samp_rate
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '1.25'
    ymin: '-1.25'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    gui_hint: 'qtgui_tab_widget_0@1 : 4, 0, 1, 2'
    label1: GFSK Demod
    name: '"GFSK Demod"'
    size: '1024'
    srate: decimated_samp_rate
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '1.25'
    ymin: '-0.25'
  states: {}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.5'
    alpha2: '0.5'
    color1: red
    color2: blue
    grid: 'True'
    gui_hint: 'qtgui_tab_widget_0@1 : 3, 0, 1, 2'
    label1: Quad Demod
    label2: Binary Slicer
    name: '"Quadrature Demod with Symbol Sync"'
    nconnections: '2'
    size: '1024'
    srate: decimated_samp_rate
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '1.25'
    ymin: '-1.25'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rf_samples
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: channel_samples
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: cfo_fix_in
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rf_samples
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: channel_samples
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: channel_samples
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: cfo_fix_in
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_sub_xx_0, '1']
- [analog_const_source_x_0_0, '0', blocks_sub_xx_0_0, '1']
- [analog_quadrature_demod_cf_1, '0', low_pass_filter_0, '0']
- [analog_quadrature_demod_cf_1_0, '0', digital_binary_slicer_fb_0_0, '0']
- [analog_quadrature_demod_cf_1_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [analog_simple_squelch_cc_0, '0', blocks_freqshift_cc_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_sink_x_0, '0']
- [band_pass_filter_0, '0', analog_simple_squelch_cc_0, '0']
- [blocks_burst_tagger_0, '0', blocks_repeat_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0_1, '0']
- [blocks_delay_0, '0', epy_block_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_freqshift_cc_0, '0', virtual_sink_2, '0']
- [blocks_moving_average_xx_0_1, '0', epy_block_0, '0']
- [blocks_moving_average_xx_1, '0', blocks_repeat_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_sub_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_sub_xx_0_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_repeat_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_repeat_0_0, '0', epy_block_0_0, '1']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_sub_xx_0_0, '0', qtgui_time_sink_x_0_0_1, '1']
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_burst_tagger_0, '0']
- [blocks_uchar_to_float_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_uchar_to_float_0_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_0_0, '0']
- [digital_binary_slicer_fb_0_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [digital_gfsk_demod_0, '0', blocks_file_sink_1, '0']
- [digital_gfsk_demod_0, '0', blocks_uchar_to_float_0, '0']
- [digital_gfsk_demod_0, '0', epy_block_1, '0']
- [digital_gfsk_demod_0, '0', epy_block_1_0, '0']
- [digital_symbol_sync_xx_0, '0', analog_quadrature_demod_cf_1_0, '0']
- [epy_block_0, '0', blocks_moving_average_xx_1, '0']
- [epy_block_0_0, '0', virtual_sink_1_0, '0']
- [epy_block_1, '0', blocks_burst_tagger_0, '1']
- [epy_block_1_0, '0', blocks_file_sink_1_0, '0']
- [fft_vxx_0, '0', blocks_multiply_const_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [low_pass_filter_0, '0', digital_binary_slicer_fb_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0_0, '0']
- [osmosdr_source_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', band_pass_filter_0, '0']
- [virtual_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [virtual_source_0, '0', qtgui_sink_x_0_0, '0']
- [virtual_source_1, '0', analog_quadrature_demod_cf_1, '0']
- [virtual_source_1, '0', digital_gfsk_demod_0, '0']
- [virtual_source_1, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_1_0, '0', qtgui_sink_x_0_1, '0']
- [virtual_source_2, '0', blocks_delay_0, '0']
- [virtual_source_2, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
