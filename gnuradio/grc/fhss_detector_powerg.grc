options:
  parameters:
    author: James Chambers
    copyright: NCC Group 2024
    description: Based on Burst Detector Reference Application by J. Gilbert (NTESS, LLC)
    generate_options: qt_gui
    id: fhss_detector_powerg
    output_language: python
    title: PowerG Capture with FHSS Utils
  states: {}

blocks:
- name: bottom_freq
  id: variable
  parameters:
    value: '912749725'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Center Freq
    start: 100e6
    step: 1e6
    stop: 2000e6
    value: overall_center_freq
  states: {}
- name: chan_spacing
  id: variable
  parameters:
    value: '129730'
  states: {}
- name: csv_output_file
  id: variable
  parameters:
    value: f'powerg_burst_bytes_{datetime.now().isoformat()}.csv'
  states: {}
- name: decim_taps
  id: variable
  parameters:
    value: firdes.low_pass_2(1, 1, output_cutoff/decimation, output_trans_width/decimation, output_attenuation)
  states: {}
- name: fir_taps
  id: variable
  parameters:
    value: firdes.low_pass_2(1, 1, 0.5*output_cutoff, 0.5*output_trans_width, output_attenuation)
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: Gain
    start: '0'
    step: '1'
    stop: '70'
    value: '0'
  states: {}
- name: num_channels
  id: variable
  parameters:
    value: '50'
  states: {}
- name: overall_center_freq
  id: variable
  parameters:
    value: bottom_freq + (chan_spacing * (num_channels-1)) / 2
  states: {}
- name: raster_size
  id: variable
  parameters:
    value: '[64,256]'
  states: {}
- name: syncwords
  id: variable
  parameters:
    value: '''00011111001101010001111100110101'''
  states: {}
- name: tf
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,2,1,1
    label: Throttle Factor
    start: '0'
    step: '1'
    stop: '40'
    value: '25'
  states: {state: disabled}
- name: threshold
  id: variable_qtgui_range
  parameters:
    comment: 20 is good but seems to capture distant packets, 30 looks better for closer packets
    gui_hint: 2,2,1,1
    label: Threshold
    start: '3'
    step: '1'
    stop: '80'
    value: '20'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_1_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_1_1
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
    log_level: warn
  states: {state: disabled}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    comment: |-
      Enable the Message Debug ---->
      and disable the throttle block
      for benchmarking performance
    mintime: '500.0'
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate/10000 * pow(10,tf/10)
    type: complex
  states: {state: disabled}
- name: burst_width
  id: parameter
  parameters:
    hide: part
    label: Burst Width [Hz]
    type: intx
    value: '100000'
  states: {}
- name: cfo_start_offset
  id: parameter
  parameters:
    label: CFO Start Offset [s]
    type: eng_float
    value: '0'
  states: {state: disabled}
- name: cfo_threshold
  id: parameter
  parameters:
    label: CFO threshold
    type: eng_float
    value: '0.5'
  states: {state: disabled}
- name: cfo_time_to_average
  id: parameter
  parameters:
    label: CFO Average Time [s]
    type: eng_float
    value: '0.0005'
  states: {state: disabled}
- name: decimation
  id: parameter
  parameters:
    label: Decimation
    type: intx
    value: '32'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport pmt\nimport numpy as np\nfrom gnuradio import gr\n\n\nPREGEN_DEWHITEN = bytes.fromhex('ffe11d9aed853324ea7ad2397097570a547d2dd86d0dba8f6759c7a2bf34ca18305393df92eca7158adcf486554e182140c4c4d5c6918acde7d14e093217df83fff00ecdf6c21912753de91cb8cb2b05aabe16ecb606ddc7b3ac63d15f1a650c98a9c96f49f6d30a456e7ac32a278c102062e26ae348c5e6f368a704998befc17f7887667be10c89ba9e740edce59502555f0b765b83eee359d6b1e82f8d3206ccd4e4b724fb69852237bd6195134608103171b571a462f379b45382ccc5f7e03fbc43b3bd7086445d4f3a07eef24a81aaaf05bbad41f7f12ceb58f497461903666af25b92fdb442919bdeb0ca0923048898b8da3852b1f93cda2941e6e27bf01fdea1d9')\n\n\nclass cc1101_dewhiten(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Perform CC1101 dewhitening on data bytes\"\"\"\n\n    def __init__(self):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='PDU CC1101 Dewhiten',   # will show up in GRC\n            in_sig=None,\n            out_sig=None\n        )\n        \n        self.msg_port_in_name = pmt.intern('pdu_in')\n        self.msg_port_out_name = pmt.intern('pdu_out')\n        self.message_port_register_in(self.msg_port_in_name)\n        self.message_port_register_out(self.msg_port_out_name)\n        self.set_msg_handler(self.msg_port_in_name, self.message_handler)\n        \n    def message_handler(self, msg):\n        meta = pmt.car(msg)\n        data = pmt.cdr(msg)\n        \n        bytez = pmt.u8vector_elements(data)\n   \n        out_meta = pmt.dict_add(meta, pmt.intern('dewhitened'), pmt.to_pmt(True))    \n        out_data = pmt.init_u8vector(len(bytez), [int(b ^ PREGEN_DEWHITEN[i]) for i, b in enumerate(bytez)])\n\n        out_msg = pmt.cons(out_meta, out_data)\n\n        self.message_port_pub(self.msg_port_out_name, out_msg)\n\n"
  states: {}
- name: fft_size
  id: parameter
  parameters:
    label: FFT Size
    type: intx
    value: '256'
  states: {}
- name: fhss_utils_cf_estimate_0
  id: fhss_utils_cf_estimate
  parameters:
    channel_freqs: ''
    comment: '[bottom_freq + chan_id * chan_spacing for chan_id in range(num_channels)]'
    method: fhss_utils.RMS
    snr_min: '10.0'
    thresh_min: '-25.0'
  states: {}
- name: fhss_utils_fft_burst_tagger_0
  id: fhss_utils_fft_burst_tagger
  parameters:
    burst_post_len: int(round((float(samp_rate)/fft_size)*post_burst_time))
    burst_pre_len: int(round((float(samp_rate)/fft_size)*pre_burst_time))
    burst_width: burst_width
    center_frequency: center_freq
    debug: 'False'
    fft_size: fft_size
    history_size: int(round((float(samp_rate)/fft_size)*hist_time))
    lookahead: int(round((float(samp_rate)/fft_size)*lookahead_time))
    max_burst_len: '0'
    max_bursts: '0'
    minoutbuf: 2048*1000
    preload_nf: '0'
    preload_nf_bool: 'False'
    sample_rate: samp_rate
    threshold: threshold
  states: {}
- name: fhss_utils_tagged_burst_to_pdu_0
  id: fhss_utils_tagged_burst_to_pdu
  parameters:
    decimation: decimation
    max_burst_time: max_burst_time
    min_burst_time: min_burst_time
    relative_center_frequency: '0.0'
    relative_sample_rate: '1.0'
    relative_span: '1.0'
    sample_rate: samp_rate
    taps: decim_taps
    threads: '3'
  states: {}
- name: fsk_burst_extractor_hier_0
  id: fsk_burst_extractor_hier
  parameters:
    burst_width: int(500e3)
    center_freq: center_freq
    cf_method: fhss_utils.RMS
    channel_freqs: '[bottom_freq + chan_id * chan_spacing for chan_id in range(num_channels)]'
    decimation: decimation
    fft_size: fft_size
    hist_time: '0.004'
    lookahead_time: '0.0005'
    max_burst_time: '0.5'
    min_burst_time: '0.001'
    n_threads: '3'
    output_attenuation: '40'
    output_cutoff: '0.45'
    output_trans_width: '0.05'
    post_burst_time: '0.00015'
    pre_burst_time: '0.00015'
    samp_rate: samp_rate
    snr_min: '10.0'
    thresh_min: '-25.0'
    threshold: threshold
  states: {state: disabled}
- name: hist_time
  id: parameter
  parameters:
    hide: part
    label: History Time [s]
    type: eng_float
    value: '0.004'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: lookahead_time
  id: parameter
  parameters:
    hide: part
    label: Lookahead Time [s]
    type: eng_float
    value: '0.0005'
  states: {}
- name: max_burst_time
  id: parameter
  parameters:
    comment: (256+8) * 8 * (1/symbols_per_second)
    hide: part
    label: Max Burst Time [s]
    type: eng_float
    value: '0.05'
  states: {}
- name: min_burst_time
  id: parameter
  parameters:
    comment: (10+8) * 8 * (1/symbols_per_second)
    hide: part
    label: Min Burst Time [s]
    type: eng_float
    value: '0.003'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      .                                                                                                                                                                                                                                  Burst Detection
      ------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
    note: SECTION
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: |-
      .                                                                                                                                                                                                                                  Tuning Parameters
      ------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
    note: SECTION
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    comment: |-
      .                                                                                                                                                                                                                                  Input
      ------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
    note: SECTION
  states: {}
- name: note_0_1
  id: note
  parameters:
    comment: |-
      .                                                                                                                                                                                                                                  FM Demod and Symbol Recovery
      ------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
    note: SECTION
  states: {}
- name: note_0_1_0
  id: note
  parameters:
    comment: |-
      .                                                                                                                                                                                                                                  Align and Raster Select Bursts				
      ------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
    note: SECTION
  states: {}
- name: note_1
  id: note
  parameters:
    comment: |-
      Both the Hier and discrete implementations
      are available here; choose one or the other.
    note: OPTION
  states: {}
- name: note_2
  id: note
  parameters:
    comment: |-
      Enable the CSV writer to save the data in the bursts to file. To open the bits in
      URH, remove the comma separations and ensure the file extetnsion is *.txt:
                  sed 's/,//g' burst_bits.csv > bits.txt
  states: {}
- name: note_2_0
  id: note
  parameters:
    note: ====> DEFRAMER
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0
    bb_gain0: '20'
    freq0: center_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: output_attenuation
  id: parameter
  parameters:
    hide: part
    label: Output Attenuation
    type: eng_float
    value: '40'
  states: {}
- name: output_cutoff
  id: parameter
  parameters:
    hide: part
    label: Output Cutoff [cycles/samp]
    type: eng_float
    value: '0.5'
  states: {}
- name: output_trans_width
  id: parameter
  parameters:
    hide: part
    label: Output Trans. Width [cycles/samp]
    type: eng_float
    value: '0.05'
  states: {}
- name: pdu_utils_pack_unpack_0
  id: pdu_utils_pack_unpack
  parameters:
    bit_order: pdu_utils.BIT_ORDER_MSB_FIRST
    mode: pdu_utils.MODE_PACK_BYTE
  states: {}
- name: pdu_utils_pdu_align_0
  id: pdu_utils_pdu_align
  parameters:
    match_mode: pdu_utils.ALIGN_FIRST_MATCH
    mode: pdu_utils.ALIGN_DROP
    offset: '0'
    syncwords: syncwords
    threshold: '1'
  states: {}
- name: pdu_utils_pdu_clock_recovery_0
  id: pdu_utils_pdu_clock_recovery
  parameters:
    binary_slice: none
    debug: 'False'
    win_type: pdu_utils.GAUSSIAN_WIN
  states: {}
- name: pdu_utils_pdu_clock_recovery_0_0
  id: pdu_utils_pdu_clock_recovery
  parameters:
    binary_slice: binary
    debug: 'False'
    win_type: pdu_utils.GAUSSIAN_WIN
  states: {}
- name: pdu_utils_pdu_fine_time_measure_0
  id: pdu_utils_pdu_fine_time_measure
  parameters:
    average_width: '10'
    buffer_percent: '15'
    post_burst_time: post_burst_time
    pre_burst_time: pre_burst_time
  states: {}
- name: pdu_utils_pdu_fir_filter_1
  id: pdu_utils_pdu_fir_filter
  parameters:
    decimation: '2'
    taps: fir_taps
  states: {}
- name: pdu_utils_pdu_head_tail_0
  id: pdu_utils_pdu_head_tail
  parameters:
    histsize: raster_size[0]
    length: raster_size[1]
    pdu_type: pdu_utils.INPUTTYPE_UNPACKED_BYTE
  states: {state: disabled}
- name: pdu_utils_pdu_quadrature_demod_cf_0
  id: pdu_utils_pdu_quadrature_demod_cf
  parameters:
    sensitivity: '1.0'
  states: {}
- name: pdu_utils_pdu_split_0_0
  id: pdu_utils_pdu_split
  parameters:
    comment: |-
      Enable the Message Debug ---->
      to see PDU Metadata printed
    pass_empty: 'False'
  states: {state: disabled}
- name: post_burst_time
  id: parameter
  parameters:
    hide: part
    label: Post Burst Time [s]
    type: eng_float
    value: 0.00008 * 2
  states: {}
- name: pre_burst_time
  id: parameter
  parameters:
    hide: part
    label: Pre Burst Time [s]
    type: eng_float
    value: '0.00008'
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    color1: '2'
    gui_hint: 3,0,1,2
    name: '"Bit Raster"'
    ncols: raster_size[1]
    nrows: raster_size[0]
    samp_rate: '1'
    type: msg_byte
    zmin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,1,1,1
    label1: ''
    name: '"FM Demodulation"'
    size: '102400'
    srate: samp_rate/decimation
    tr_delay: '.001'
    tr_level: '0.000001'
    type: msg_float
    update_time: '0.01'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,2,1,1
    label1: ''
    marker1: '0'
    name: '"Soft Symbols"'
    size: '102400'
    srate: '1'
    style1: '0'
    tr_delay: '.001'
    tr_level: '0.000001'
    type: msg_float
    update_time: '0.01'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/decimation/2
    fc: '0'
    fftsize: '128'
    gui_hint: 1,0,1,1
    name: '"Burst Spectrogram"'
    showports: 'True'
    type: msg_complex
    update_time: '0.005'
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,0,1,3
    int_max: '0'
    int_min: '-120'
    name: '"Input Spectrogram"'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    short_id: r
    type: intx
    value: int(8e6)
  states: {}
- name: sandia_utils_csv_writer_0_0
  id: sandia_utils_csv_writer
  parameters:
    add_metadata: 'False'
    data_type: '''uint8'''
    file: /tmp/burst_bits.csv
    metadata_format: '''start_offset(uint64), center_frequency(double), symbol_rate(uint64)'''
    precision: '0'
  states: {state: disabled}
- name: sandia_utils_csv_writer_0_0_0
  id: sandia_utils_csv_writer
  parameters:
    add_metadata: 'True'
    data_type: '''uint8'''
    file: csv_output_file
    metadata_format: '''start_offset(uint64), start_time(double), start_time_offset(double), center_frequency(double), dewhitened(bool)'''
    precision: '0'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: input
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: bursts
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: hard_syms
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: input
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: input
  states: {}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: bursts
  states: {}
- name: virtual_source_0_2_0
  id: virtual_source
  parameters:
    stream_id: hard_syms
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0_1_0, print]
- [blocks_throttle_0_0, '0', virtual_sink_0, '0']
- [epy_block_0, pdu_out, blocks_message_debug_0_1_1, print]
- [epy_block_0, pdu_out, sandia_utils_csv_writer_0_0_0, in]
- [fhss_utils_cf_estimate_0, out, pdu_utils_pdu_fir_filter_1, pdu_in]
- [fhss_utils_fft_burst_tagger_0, '0', fhss_utils_tagged_burst_to_pdu_0, '0']
- [fhss_utils_tagged_burst_to_pdu_0, cpdus, fhss_utils_cf_estimate_0, in]
- [fsk_burst_extractor_hier_0, pdu_out, virtual_sink_0_0, '0']
- [osmosdr_source_0, '0', virtual_sink_0, '0']
- [pdu_utils_pack_unpack_0, pdu_out, epy_block_0, pdu_in]
- [pdu_utils_pdu_align_0, pdu_out, pdu_utils_pack_unpack_0, pdu_in]
- [pdu_utils_pdu_align_0, pdu_out, pdu_utils_pdu_head_tail_0, pdu_in]
- [pdu_utils_pdu_align_0, pdu_out, sandia_utils_csv_writer_0_0, in]
- [pdu_utils_pdu_clock_recovery_0, pdu_out, pdu_utils_pdu_split_0_0, pdu_in]
- [pdu_utils_pdu_clock_recovery_0, pdu_out, qtgui_time_sink_x_0_0_0_0_0_0_0_0, in]
- [pdu_utils_pdu_clock_recovery_0_0, pdu_out, virtual_sink_0_0_0, '0']
- [pdu_utils_pdu_fine_time_measure_0, pdu_out, virtual_sink_0_0, '0']
- [pdu_utils_pdu_fir_filter_1, pdu_out, pdu_utils_pdu_fine_time_measure_0, pdu_in]
- [pdu_utils_pdu_head_tail_0, head, qtgui_time_raster_sink_x_0, in]
- [pdu_utils_pdu_quadrature_demod_cf_0, fpdus, pdu_utils_pdu_clock_recovery_0, pdu_in]
- [pdu_utils_pdu_quadrature_demod_cf_0, fpdus, pdu_utils_pdu_clock_recovery_0_0, pdu_in]
- [pdu_utils_pdu_quadrature_demod_cf_0, fpdus, qtgui_time_sink_x_0_0_0_0_0, in]
- [pdu_utils_pdu_split_0_0, dict, blocks_message_debug_0_1, print]
- [virtual_source_0, '0', fhss_utils_fft_burst_tagger_0, '0']
- [virtual_source_0, '0', fsk_burst_extractor_hier_0, '0']
- [virtual_source_0_0, '0', blocks_probe_rate_0, '0']
- [virtual_source_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [virtual_source_0_2, '0', pdu_utils_pdu_quadrature_demod_cf_0, cpdus]
- [virtual_source_0_2, '0', qtgui_waterfall_sink_x_0, in]
- [virtual_source_0_2_0, '0', pdu_utils_pdu_align_0, pdu_in]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
